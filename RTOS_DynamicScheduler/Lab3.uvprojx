# Keil uVision project Lab3.uvprojx, settings and files
target Lab3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab3.c
    ../RTOS_Labs_common/: OS.c Interpreter.c ST7735.c eDisk.c efile.c osasm.s UART0int.c ADC.c
    ../inc/: LaunchPad.c PLL.c ADCSWTrigger.c ADCT0ATrigger.c LPF.c WTimer0A.c cr4_fft_64_stm32.s PID_stm32.s IRDistance.c TCB.c TCB.h Timer4A.c Timer4A.h Timer5A.c Timer5A.h Timer2A.c Timer2A.h Timer3A.c
software components: CMSIS:CORE 5.0.2
